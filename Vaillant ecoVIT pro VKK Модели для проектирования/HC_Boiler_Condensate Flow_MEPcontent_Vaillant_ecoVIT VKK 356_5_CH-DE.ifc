Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-05-05T10:09:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 05 10:09:12 2020 * Host: LCOLTOI-RO-DE * Database: C:\Users\lcoltoi\AppData\Local\Temp\{20145A9C-7E6F-4AC7-BD8A-3E2562608AE6}\ifc * Database version: 5507 * Database creation date: Tue May 05 10:09:10 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 05 10:09:10 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 05 10:09:10 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBoiler: ecoVIT VKK 356/5, HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT pro VKK 5_CH-DE:ecoVIT VKK 356/5:1322405
In: V00
Type - Material: Color RGB 244-244-244, Color RGB 120-120-120, Color RGB 006-085-144, Color RGB 100-100-100
Type - Dimensions - Condensate Connection: 19 mm; Depth: 700 mm; Flue Gas Diameter: 80 mm; Gas Diameter: 19.05 mm; Height: 1245 mm; Hydronic Return Diameter: 25.4 mm; Hydronic Supply Diameter: 25.4 mm; Supply Air Diameter: 125 mm; Use Nominal Diameter: yes; Width: 570 mm
Type - Electrical - Loads - Voltage: 230 V
Type - Identity Data - Article Description: VA Gas-Brennwertkessel; Article Type: ecoVIT VKK 356/5; Base Family Version: 12.14; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: VA Gas-Brennwertkessel; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.14; Manufacturer: Vaillant; Manufacturer Art. No.: 0010031908; Manufacturer URL: https://www.vaillant.ch/partnernet/; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: ecoVIT VKK 356/5; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: ecoVIT; Revit Version: 2018; Type Name: ecoVIT VKK 356/5; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 006-085-144; Grey: Color RGB 100-100-100; Light Grey: Color RGB 120-120-120; White: Color RGB 244-244-244
Type - Mechanical - Drain Fixture Units: 0; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Tap Capacity at 40°C: 0 m3/s
Type - Mechanical - Flow - Flue Gas Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Type - Mechanical - Loads - Heating Power: 376737
Type - Other - Category: Mechanical Equipment; Back Clearance: 300 mm; Family Name: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT pro VKK 5_CH-DE; Left Clearance: 500 mm; Top Clearance: 500 mm
Type - Text - Pipe Type Category: M561
Pset_ManufacturerTypeInformation - Manufacturer: Vaillant
Constraints - Offset: 0 mm
Dimensions - Area: 7.0568 m2; Volume: 0.493144 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Undefined,Hydronic Supply,Hydronic Return,Sanitary,Power,Supply Air,Other
Other - Family: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT pro VKK 5_CH-DE: ecoVIT VKK 356/5; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT pro VKK 5_CH-DE: ecoVIT VKK 356/5; Feet Height: 10 mm; Height Safe: 1255 mm; Legs Height Safe: 10 mm; Type: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT pro VKK 5_CH-DE: ecoVIT VKK 356/5; Type Id: HC_Boiler_Condensate Flow_MEPcontent_Vaillant_ecoVIT pro VKK 5_CH-DE: ecoVIT VKK 356/5
Phasing - Phase Created: 3. New Construction
Visibility - Service Space: no
